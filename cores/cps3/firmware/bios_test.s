    .section .text

    .equ STACK_TOP,    0x0207fff0
    .equ START_ADDR,   0x00000400

    .equ BCR2_ADDR,    0xffffffe4
    .equ BCR2_VALUE,   0xa55a00e8

    .equ PAL_BASE,     0x04080000
    .equ SSMAP_BASE,   0x05040000
    .equ SSCHAR_BASE,  0x05048000
    .equ SSREG_BASE,   0x05050000
    .equ SS_PAL_BASE,  SSREG_BASE + 0x24

    .org 0x00000000
    .long START_ADDR
    .long STACK_TOP
    .long START_ADDR
    .long STACK_TOP

    .org START_ADDR
    .global _start
_start:
    mov.l lit_stack, r15
    mov.l lit_bcr2_addr, r0
    mov.l lit_bcr2_value, r1
    mov.l r1, @r0

    bsr init_palette
    nop
    bsr init_ss_regs
    nop
    bsr load_font
    nop
    bsr write_message
    nop

idle:
    bra idle
    nop

init_palette:
    mov.l lit_pal_white, r1
    mov.w lit_white, r0
    mov.w r0, @r1
    rts
    nop

init_ss_regs:
    mov.l lit_ss_pal_base, r1
    mov #0, r0
    mov.b r0, @r1
    rts
    nop

load_font:
    mov.l lit_glyph_data, r4
    mov.l lit_sschar_base, r5
    mov #6, r6
glyph_loop:
    mov #8, r7
row_loop:
    mov.b @r4+, r0
    mov.b r0, @r5
    mov.b @r4+, r0
    mov.b r0, @(2,r5)
    mov.b @r4+, r0
    mov.b r0, @(4,r5)
    mov.b @r4+, r0
    mov.b r0, @(6,r5)
    add #8, r5
    add #-1, r7
    tst r7, r7
    bf row_loop
    add #-1, r6
    tst r6, r6
    bf glyph_loop
    rts
    nop

write_message:
    mov.l lit_message_codes, r4
    mov.l lit_message_map, r5
    mov #9, r6
map_loop:
    mov.b @r4+, r0
    mov.b r0, @r5
    mov #0, r0
    mov.b r0, @(2,r5)
    add #4, r5
    add #-1, r6
    tst r6, r6
    bf map_loop
    rts
    nop

    .align 4
lit_stack:
    .long STACK_TOP
lit_bcr2_addr:
    .long BCR2_ADDR
lit_bcr2_value:
    .long BCR2_VALUE
lit_pal_white:
    .long PAL_BASE + 2
lit_ss_pal_base:
    .long SS_PAL_BASE + 1
lit_sschar_base:
    .long SSCHAR_BASE + 64 + 1
lit_glyph_data:
    .long glyph_data
lit_message_map:
    .long SSMAP_BASE + (15 * 64 + 20) * 4 + 1
lit_message_codes:
    .long message_codes
lit_white:
    .word 0x7fff

message_codes:
    .byte 1, 2, 3, 4, 0, 5, 6, 4, 5

    .align 4
glyph_data:
    /* 1: B */
    .byte 0x10, 0x11, 0x11, 0x00
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x11, 0x11, 0x00
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x11, 0x11, 0x00
    .byte 0x00, 0x00, 0x00, 0x00
    /* 2: I */
    .byte 0x10, 0x11, 0x11, 0x01
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x10, 0x11, 0x11, 0x01
    .byte 0x00, 0x00, 0x00, 0x00
    /* 3: O */
    .byte 0x00, 0x11, 0x11, 0x00
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x00, 0x11, 0x11, 0x00
    .byte 0x00, 0x00, 0x00, 0x00
    /* 4: S */
    .byte 0x00, 0x11, 0x11, 0x00
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x00
    .byte 0x00, 0x11, 0x11, 0x00
    .byte 0x00, 0x00, 0x00, 0x01
    .byte 0x10, 0x00, 0x00, 0x01
    .byte 0x00, 0x11, 0x11, 0x00
    .byte 0x00, 0x00, 0x00, 0x00
    /* 5: T */
    .byte 0x10, 0x11, 0x11, 0x01
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x10, 0x01, 0x00
    .byte 0x00, 0x00, 0x00, 0x00
    /* 6: E */
    .byte 0x10, 0x11, 0x11, 0x01
    .byte 0x10, 0x00, 0x00, 0x00
    .byte 0x10, 0x00, 0x00, 0x00
    .byte 0x10, 0x11, 0x11, 0x00
    .byte 0x10, 0x00, 0x00, 0x00
    .byte 0x10, 0x00, 0x00, 0x00
    .byte 0x10, 0x11, 0x11, 0x01
    .byte 0x00, 0x00, 0x00, 0x00
    /* 0: space data is left zero in SS character RAM. */
